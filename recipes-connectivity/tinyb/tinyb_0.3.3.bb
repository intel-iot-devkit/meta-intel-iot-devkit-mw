require tinyb.inc

SRC_URI = "git://github.com/intel-iot-devkit/tinyb.git;protocol=git;tag=v0.3.3 \
          "
