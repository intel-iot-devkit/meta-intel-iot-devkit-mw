require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;branch=gt"
SRCREV = "9efeceb9af75809c48efbca55636639e3cd08617"
